Commit message: fix the urdf's bug

File: mani_skill2/assets/descriptions/xarm7_reduced_gripper_d435.urdf (robot description, URDF)
Before this commit: robot xarm7, 23 links, 22 joints
Joints:
- joint gripper_fix: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.005 rpy=0 0 0
